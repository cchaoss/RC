# Keil uVision project remote_xn297.uvprojx, settings and files
target RX (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: remote_xn297 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\Inc;.\Lib\inc;.\StartUp;.\Src;.\Lib\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./Src/: main.c stm32f10x_it.c stmflash.c Sys_Fun.c xn297.c key.c led.c spi.c uart.c timer.c protocol.c stick.c delay.c lt8900.c
  group LIB
    ./Lib/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group StratUp
    ./StartUp/: system_stm32f10x.c core_cm3.c startup_stm32f10x_md.s
